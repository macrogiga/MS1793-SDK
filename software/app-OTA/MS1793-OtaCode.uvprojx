# Keil uVision project MS1793-OtaCode.uvprojx, settings and files
target APP-OtaCode (ARM-ADS)
  device: MM32L073PF MindMotion
  pack: MindMotion.MM32L0xx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MS1793-OTACODE +hex
  AfterMake: fromelf --bin --output .\Obj\MS1793-OTACODE.bin .\Obj\MS1793-OTACODE.axf
  c flags: OneElfS=1
  c define: MG_OTA_SUPPORT BLE_PAIR_SUPPORT
  c include: ..\MM32x031\CMSIS\KEIL_CORE;..\MM32x031\HAL_lib\inc;..\MM32x031\Include;..\BSP;..\Src\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8001010 size 0x77f0
  memory RVCT9: RAM 0x200000c0 size 0x1f40
  group startup
    ../MM32x031/Source/: system_MM32x031.c
    ../MM32x031/Source/KEIL_StartAsm/: startup_MM32x031.s
  group USER
    ../Src/lib/: mg_BLEOTA_lib_m0.lib
    ./: app.c main.c
  group HALlib
    ../MM32x031/HAL_lib/src/: HAL_adc.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group BSP
    ./: mm32f031_it.c BSP.c
