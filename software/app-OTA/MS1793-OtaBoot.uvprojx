# Keil uVision project MS1793-OtaBoot.uvprojx, settings and files
target APP-OTABOOT (ARM-ADS)
  device: MM32L073PF MindMotion
  pack: MindMotion.MM32L0xx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MS1793-OTABOOT +hex
  c flags: OneElfS=1
  c include: ..\MM32x031\CMSIS\KEIL_CORE;..\MM32x031\HAL_lib\inc;..\MM32x031\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x800
  memory RVCT9: RAM 0x20000000 size 0x2000
  group startup
    ../MM32x031/Source/: system_MM32x031.c
    ../MM32x031/Source/KEIL_StartAsm/: startup_MM32x031.s
  group USER
    ./: main-boot.c
  group HALlib
    ../MM32x031/HAL_lib/src/: HAL_adc.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
