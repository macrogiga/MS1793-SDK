# Keil uVision project MS1793-AirSync.uvprojx, settings and files
target App-AirSync (ARM-ADS)
  device: MM32L073PT MindMotion
  pack: MindMotion.MM32L0xx_DFP.1.0.1
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MS1793-AirSync +hex
  c flags: OneElfS=1 uC99=1
  c include: ..\MM32x031\HAL_lib\inc;..\MM32x031\Include;..\BSP;..\Src\inc;..\MM32x031\CMSIS\KEIL_CORE;..\Src\IWDG;.\crc32;.\crypt;.\protobuf
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group startup
    ../MM32x031/Source/: system_MM32x031.c
    ../MM32x031/Source/KEIL_StartAsm/: startup_MM32x031.s
  group BSP
    ./: BSP.c mm32f031_it.c
  group HALlib
    ../MM32x031/HAL_lib/src/: HAL_adc.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group src
    ../Src/lib/: mg_BLE_lib_m0.lib
    ./: app.c main.c
  group IWDG
    ../Src/IWDG/: iwdg.c
  group protobuf
    ./crc32/: crc32.c
    ./crypt/: aes_crypt.c
    ./crypt/aes/: aes_cbc.c aes_core.c cbc128.c
    ./protobuf/: epb.c epb_MmBp.c epb_WristBand.c
